# IAR project Legendary.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 NXP KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG_MODE; ARM_MATH_CM0PLUS; MKEA128
  ICCARM.CCIncludePath2: ..\App; ..\App\Inc; ..\Board\Inc; ..\Chip\inc; ..\Chip\inc\IAR; ..\Chip\inc\kinetis; ..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Legendary.bin
  ILINK.IlinkOutputFile: Legendary.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_KEA128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ARM_MATH_CM0PLUS; MKEA128
  ICCARM.CCOptLevel: 3
  group App
    ../App/Inc/: include.h MKEA128_conf.h MKEA128_it.h PORT_cfg.h
    ../App/: main.c MKEA128_conf.c MKEA128_it.c
  group Board
    ../Board/src/: control.c dianci.c Double_Motor.c Init.c Measurement_speed.c MPU6050.c My_I2C.c PID.C VCAN_ASCII.c VCAN_computer.c VCAN_key.c VCAN_key_event.c VCAN_LCD.c VCAN_LCD_CH.c VCAN_LCD_ST7735R.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group Chip
    ../Chip/inc/: common.h
    ../Chip/src/: KEA_adc.c KEA_ftm.c KEA_gpio.c KEA_PIT.c KEA_port.c KEA_SysTick.c KEA_uart.c KEA_wdog.c misc.c vectors.c
    ../Chip/src/IAR/: startup_SKEAZ1284.s system_SKEAZ1284.c
